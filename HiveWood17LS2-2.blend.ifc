Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: HiveWood17LS2-2.blend.ifc
Time: 2023-04-12T14:21:46+03:00
Written by: IfcOpenShell v0.7.0-476ab506d
Made in: BlenderBIM 0.0.230304
Authorization: Nobody

# IfcActuator (365)
PredefinedType: ELECTRICACTUATOR
Name
IfcActuator/Puuk__te_suur_LS
51 x 1
54 x 2
52 x 3
53 x 4
50 x 5
54 x 6
50 x 7
